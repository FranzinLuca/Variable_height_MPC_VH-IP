Commit message: fix zero-mass obstacle

File: urdf/obstacle.urdf (robot description, URDF)
Before this commit: robot obstacle, 2 links, 1 joints
Links:
- link obstacle_link: mass 0 -> 1e-8
